<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Projet_robot_recepteur.ewp</path>
  </project>
  <batchBuild/>
</workspace>


